IMAGE_INSTALL_append = " \
    intel6300-fw \
    wireless-tools \
    wpa-supplicant \
    usbutils \
    oxalis-test \
"
